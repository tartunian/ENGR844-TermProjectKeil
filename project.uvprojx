# Keil uVision project project.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4c123GH6PM PART_TM4C123GH6PM
  c include: C:\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: common.h lwipopts.h main.c startup_rvmdk.S
  group drivers/enc28j60
    ./drivers/enc28j60/: enc28j60.c enc28j60.h initHw.c initHw.h led.h wait.c wait.h
  group lib
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/: uart.c
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
